FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI_append_auvidea-j120 = " \
    file://0001-Enable-USB-2.0.patch \
    "
